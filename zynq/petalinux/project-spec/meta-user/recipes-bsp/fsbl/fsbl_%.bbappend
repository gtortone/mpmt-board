
YAML_COMPILER_FLAGS_append = " -DFSBL_DEBUG_INFO"
